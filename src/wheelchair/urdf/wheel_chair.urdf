Commit message: Umut

File: src/wheelchair/urdf/wheel_chair.urdf (robot description, URDF)
Before this commit: robot wheel_chair, 8 links, 7 joints
Joints:
- joint rp_laser_back_joint: origin xyz=-0.36833 0.305 0.25299 rpy=0 0 -0.35 -> xyz=-0.36833 0.305 0.25299 rpy=0 0 -0.436332
